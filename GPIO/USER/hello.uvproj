# Keil uVision project hello.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: hello +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32_FWLIB\inc;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group FWLIB
    ../STM32_FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c
